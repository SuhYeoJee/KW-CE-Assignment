# Keil uVision project problem3.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: problem3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  group Source Group 1
    ./: oddsum1.s oddsum2.s oddsum3.s
